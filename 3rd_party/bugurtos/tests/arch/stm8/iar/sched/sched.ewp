# IAR project sched.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S208MB STM8S208MB
  General.GenCodeModel: 2
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\..\..\..\..\kernel; ..\..\..\..\..\kernel\default; ..\..\..\..\..\arch\stm8\iar; ..
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: sched.srec
  ILINK.IlinkOutputFile: sched.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ../../../../main/sched/: main.c
    ../: test_func.c test_func.h
  group arch
    ../../../../../arch/stm8/iar/: bugurt_port.c bugurt_port.h bugurt_port_asm.S bugurt_proc_stack_init.c
  group kernel
    ../../../../../kernel/: bugurt.h crit_sec.c crit_sec.h index.c index.h item.c item.h kernel.c kernel.h pcounter.c pcounter.h pitem.c pitem.h proc.c proc.h sched.c sched.h sync.c sync.h syscall.c syscall.h timer.c timer.h vint.c vint.h xlist.c xlist.h
  group kernel/default
    ../../../../../kernel/default/: syscall_api.h syscall_routines.h syscall_table.h
